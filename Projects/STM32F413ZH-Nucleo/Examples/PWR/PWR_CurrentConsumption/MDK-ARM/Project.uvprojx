# Keil uVision project Project.uvprojx, settings and files
target STM32413ZH_Nucleo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32413ZH_Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c
  group Drivers/BSP/STM32413ZH_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_lp_modes.c main.c stm32f4xx_hal_msp.c
  group Example/MDK-ARM
    ./: startup_stm32f413xx.s
software components: CMSIS:CORE 4.3.0
