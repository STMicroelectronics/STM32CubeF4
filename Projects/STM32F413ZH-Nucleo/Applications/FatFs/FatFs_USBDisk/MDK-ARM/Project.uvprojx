# Keil uVision project Project.uvprojx, settings and files
target STM32F413ZH_Nucleo (ARM-ADS)
  device: STM32F413ZHTx STMicroelectronics
  cpu: IROM(0x08000000-0x817FFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4-Nucleo_144
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Adafruit_Shield;../../../../../../Drivers/BSP/Components/st7735;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src
  asm include: ../Inc
  library: MicroLIB
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sdram.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c
  group Application/User
    ../Src/: usbh_conf.c main.c stm32f4xx_it.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_core.c usbh_ctlreq.c usbh_ioreq.c
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
software components: CMSIS:CORE 4.3.0
