<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_MSC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBH_MSC</project>
        <configuration>STM32446ZE-NUCLEO_144_USBH-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


