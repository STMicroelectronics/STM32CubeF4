<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_HID.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBH_HID</project>
        <configuration>STM32446ZE_NUCLEO_144_USBH-FS</configuration>
      </member>
      <member>
        <project>USBH_HID</project>
        <configuration>STM32446ZE_NUCLEO_144_USBH-FS</configuration>
      </member>
      <member>
        <project>USBH_HID</project>
        <configuration>STM32446ZE_NUCLEO_144_USBH-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


