# Keil uVision project Project.uvprojx, settings and files
target STM32F411-Nucleo (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F411-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F411xE,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc
  library: MicroLIB
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_LL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_rcc.c stm32f4xx_ll_spi.c stm32f4xx_ll_utils.c
  group Example/User
    ../Src/: main.c stm32f4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32f411xe.s
software components: CMSIS:CORE 4.3.0
