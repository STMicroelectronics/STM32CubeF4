# Keil uVision project Project.uvprojx, settings and files
target STM32446E-EVAL_USBH-FS (ARM-ADS)
  device: STM32F446ZETx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32446E-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_FS,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/Include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Drivers/BSP/STM32446E_EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/ili9325;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log
  asm include: ../Inc
  library: MicroLIB
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_hcd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_hcd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma.c stm32f4xx_hal_fmpi2c_ex.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c ili9325.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152.c
  group Doc
    ../: readme.txt readme.txt
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c usbh_core.c usbh_ioreq.c usbh_ctlreq.c usbh_pipes.c usbh_core.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c lcd_log.c
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio_dma.c usbh_diskio_dma.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s startup_stm32f446xx.s
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_lcd.c stm32446e_eval_io.c stm32446e_eval.c stm32446e_eval_lcd.c stm32446e_eval_io.c stm32446e_eval.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c queue.c croutine.c timers.c list.c tasks.c queue.c croutine.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
  group Application/User
    ../Src/: menu.c main.c explorer.c file_operations.c stm32f4xx_hal_timebase_tim.c usbh_conf.c stm32f4xx_it.c menu.c main.c explorer.c file_operations.c stm32f4xx_hal_timebase_tim.c usbh_conf.c stm32f4xx_it.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c
target STM32446E-EVAL_USBH-HS (ARM-ADS)
  device: STM32F446ZETx STMicroelectronics
  cpu: as above
  output: STM32446E-EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_HS,USE_IOEXPANDER
  c misc: --C99
  c include: as above
  asm include: ../Inc
  library: MicroLIB
software components: CMSIS:CORE 4.3.0
