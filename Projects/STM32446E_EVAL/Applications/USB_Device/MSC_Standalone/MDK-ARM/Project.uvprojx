# Keil uVision project Project.uvprojx, settings and files
target STM32446E-EVAL_USBD-HS (ARM-ADS)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32446E-EVAL_USBD-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_HS,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_io.c stm32446e_eval_sd.c stm32446e_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c stm32f4xx_ll_fmc.c
  group Application/User
    ../Src/: stm32f4xx_it.c usbd_desc.c usbd_storage.c main.c usbd_conf.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c usbd_msc.c
target STM32446E-EVAL_USBD-FS (ARM-ADS)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: as above
  output: STM32446E-EVAL_USBD-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_FS,USE_IOEXPANDER
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 3.40.0
