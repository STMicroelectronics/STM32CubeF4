# Keil uVision project Project.uvprojx, settings and files
target STM32446E_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32446E_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\Fonts;..\..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_can.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_dma.c
  group Example/MDK-ARM
    ./: startup_stm32f446xx.s
  group Example/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
