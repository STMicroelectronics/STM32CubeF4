<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_CDC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>STM32_USBD_CDC</name>
      <member>
        <project>USBD_CDC</project>
        <configuration>STM324xG-EVAL_USBD-FS</configuration>
      </member>
      <member>
        <project>USBD_CDC</project>
        <configuration>STM324xG-EVAL_USBD-HS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


