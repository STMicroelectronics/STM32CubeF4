# Keil uVision project Project.uvprojx, settings and files
target STM324xG_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F417IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F417xx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM324xG_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_timebase_rtc_wakeup.c main.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval.c stm324xg_eval_io.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c
  group Example/MDK-ARM
    ./: startup_stm32f417xx.s
software components: CMSIS:CORE 4.3.0
