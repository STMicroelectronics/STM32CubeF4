# Keil uVision project Project.uvprojx, settings and files
target STM32F4-DISCO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4_DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_STM32F4_DISCO,USE_HAL_DRIVER
  c include: ../Inc;../../../../Drivers//CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers//STM32F4xx_HAL_Driver/Inc;../../../../Drivers//BSP/STM32F4-Discovery;../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c
    ../../../../Drivers/BSP/Components/lis3dsh/: lis3dsh.c
    ../../../../Drivers/BSP/Components/lis302dl/: lis302dl.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hash.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_usart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_irda.c stm32f4xx_hal_sram.c stm32f4xx_hal_pccard.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rtc.c stm32f4xx_hal_dac.c stm32f4xx_hal_rng.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_cryp.c stm32f4xx_hal_eth.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_crc.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr.c stm32f4xx_hal_hcd.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_i2s.c stm32f4xx_hal_wwdg.c stm32f4xx_hal.c stm32f4xx_hal_flash.c
  group Drivers/BSP/STM32F4_DISCO
    ../../../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery_accelerometer.c stm32f4_discovery.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_conf.c usbd_desc.c main.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
software components: CMSIS:CORE 4.3.0
