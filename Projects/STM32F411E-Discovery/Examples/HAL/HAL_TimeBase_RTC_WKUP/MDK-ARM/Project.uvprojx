# Keil uVision project Project.uvprojx, settings and files
target STM32F411E-Discovery (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411VEHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F411E-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F411E_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F411E-Discovery;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F411E-Discovery
    ../../../../../../Drivers/BSP/STM32F411E-Discovery/: stm32f411e_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_timebase_rtc_wakeup.c main.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c
  group Example/MDK-ARM
    ./: startup_stm32f411xe.s
software components: CMSIS:CORE 4.3.0
