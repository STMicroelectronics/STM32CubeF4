<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\touchgfx_demo2015_800x480.ewp</path>
  </project>
  <batchBuild/>
</workspace>
