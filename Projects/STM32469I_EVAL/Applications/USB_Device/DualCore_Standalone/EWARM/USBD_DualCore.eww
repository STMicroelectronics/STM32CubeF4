<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_DualCore.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBD_DualCore</project>
        <configuration>STM32469I-EVAL_USBD</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


