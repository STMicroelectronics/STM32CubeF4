<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_MSC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBD_MSC</project>
        <configuration>STM32469I-EVAL_USBD-FS</configuration>
      </member>
      <member>
        <project>USBD_MSC</project>
        <configuration>STM32469I-EVAL_USBD-HS</configuration>
      </member>
      <member>
        <project>USBD_MSC</project>
        <configuration>STM32469I-EVAL_USBD-HS-IN-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


