# Keil uVision project Project.uvprojx, settings and files
target STM32469I-EVAL_USBH (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32469I-EVAL_USBH
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_EVAL,USE_USB_FS,USE_IOEXPANDER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Drivers/BSP/STM32469I_EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: usbh_conf.c dual_menu.c main.c stm32f4xx_it.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/FatFS/Drivers
    ../Src/: usbh_diskio_dma.c
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_parser.c usbh_hid.c usbh_hid_mouse.c usbh_hid_keybd.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/User/MSC
    ../Src/: msc_menu.c file_operations.c explorer.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_uart.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_gpio.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_hcd.c stm32f4xx_hal_sram.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_i2c.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c
  group Application/User/HID
    ../Src/: mouse.c keyboard.c hid_menu.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c usbh_core.c
  group Drivers/BSP/STM32469i_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_lcd.c stm32469i_eval_sdram.c stm32469i_eval.c stm32469i_eval_io.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
software components: CMSIS:CORE 4.3.0
