# IAR project USBH_HID.ewp, settings and files
configuration STM32469I-EVAL_USBH-HS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; USE_STM32469I_EVAL; USE_USB_HS; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32469I_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152; ..\..\..\..\..\..\Drivers\BSP\Components\ili9325; Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\Include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32469I-EVAL_USBH-HS.hex
  ILINK.IlinkOutputFile: STM32469I-EVAL_USBH-HS.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32469I-EVAL_USBH-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; USE_STM32469I_EVAL; USE_USB_FS; USE_IOEXPANDER
  OBJCOPY.OOCOutputFile: STM32469I-EVAL_USBH-FS.hex
  ILINK.IlinkOutputFile: STM32469I-EVAL_USBH-FS.out
configuration STM32469I-EVAL_USBH-HS-IN-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; USE_STM32469I_EVAL; USE_USB_HS; USE_USB_HS_IN_FS; USE_IOEXPANDER
  OBJCOPY.OOCOutputFile: STM32469I-EVAL_USBH-HS-IN-FS.hex
  ILINK.IlinkOutputFile: STM32469I-EVAL_USBH-HS-IN-FS.out
  group Application/EWARM
    ./: startup_stm32f469xx.s
  group Application/User
    ../Src/: keyboard.c main.c menu.c mouse.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c usbh_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Drivers/BSP/STM32469i_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval.c stm32469i_eval_io.c stm32469i_eval_lcd.c stm32469i_eval_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
