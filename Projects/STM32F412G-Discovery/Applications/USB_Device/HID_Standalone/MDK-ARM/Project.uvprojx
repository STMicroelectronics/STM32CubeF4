# Keil uVision project Project.uvprojx, settings and files
target STM32F412G-Discovery (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F412G-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32412G-Discovery;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F412G-Discovery
    ../../../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_sram.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_usb.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: usbd_conf.c main.c stm32f4xx_it.c usbd_desc.c
software components: CMSIS:CORE 4.3.0
