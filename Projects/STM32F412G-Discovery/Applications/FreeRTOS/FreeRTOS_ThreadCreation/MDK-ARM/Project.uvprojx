# Keil uVision project Project.uvprojx, settings and files
target STM32F412G-Discovery (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F412G-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32412G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F412G-Discovery
    ../../../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c tasks.c list.c
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.3.0
