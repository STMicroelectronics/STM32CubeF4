# Keil uVision project Project.uvprojx, settings and files
target STM32412G_DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32412G_DISCOVERY
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY,USE_USB_FS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/BSP/STM32412G-Discovery;../../../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32412G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery_sd.c stm32412g_discovery.c stm32412g_discovery_lcd.c
  group Middlewares/STM32_USBH_Library/Class/Audio
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ls016b8uy/: ls016b8uy.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Application/User
    ../Src/: usbh_conf.c explorer.c stm32f4xx_it.c menu.c main.c audio.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_pipes.c usbh_ctlreq.c
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c sd_diskio_dma.c
software components: CMSIS:CORE 5.0.1
