# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_pwr.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f413xx.s
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery_lcd.c stm32f413h_discovery.c
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
software components: CMSIS:CORE 4.3.0
