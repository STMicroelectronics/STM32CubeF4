# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000-0x817FFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F413xx,USE_STM32F413H_DISCOVERY,TS_MULTI_TOUCH_SUPPORTED
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Log;../../../../../Utilities/Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c ft3x67.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32F413H_DISCOVERY
    ../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c stm32f413h_discovery_audio.c stm32f413h_discovery_lcd.c stm32f413h_discovery_psram.c stm32f413h_discovery_qspi.c stm32f413h_discovery_sd.c stm32f413h_discovery_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group Example/MDK-ARM
    ./: startup_stm32f413xx.s
  group Example/User
    ../Src/: audio.c audio_rec_dfsdm.c lcd.c log.c main.c psram.c qspi.c sd.c stm32f4xx_it.c touchscreen.c ts_calibration.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
target USE_STM32F413H_DISCOVERY_REVE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: Project +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F413xx,USE_STM32F413H_DISCOVERY_REVE,TS_MULTI_TOUCH_SUPPORTED
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 4.3.0
