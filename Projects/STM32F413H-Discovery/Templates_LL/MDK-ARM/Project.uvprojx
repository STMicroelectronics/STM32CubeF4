# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_LL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_rng.c stm32f4xx_ll_dac.c stm32f4xx_ll_gpio.c stm32f4xx_ll_usart.c stm32f4xx_ll_spi.c stm32f4xx_ll_utils.c stm32f4xx_ll_tim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_dma.c stm32f4xx_ll_crc.c stm32f4xx_ll_lptim.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_i2c.c stm32f4xx_ll_adc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f413xx.s
  group Example/User
    ../Src/: stm32f4xx_it.c main.c
software components: CMSIS:CORE 4.3.0
