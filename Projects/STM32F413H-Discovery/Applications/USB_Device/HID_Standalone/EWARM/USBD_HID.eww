<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_HID.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBD_HID</project>
        <configuration>STM32F413H-DISCOVERY_USBD-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>

