# Keil uVision project Project.uvprojx, settings and files
target STM32F429I-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F429I-Discovery_TouchGFX_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ST,STM32F429xx,USE_BPP=16,CORE_CM4F
  c include: ../Config;../Core/Inc;../Gui/target;../Gui/gui/include;../Gui/target/include;../Gui/platform/os;../Gui/generated/fonts/include;../Gui/generated/images/include;../Gui/generated/texts/include;../Gui/generated/gui_generated/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F429I-Discovery;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  asm define: ST,STM32F429xx,USE_BPP=16,CORE_CM4F
  asm include: ../Config;../Core/Inc;../Gui/target;../Gui/gui/include;../Gui/target/include;../Gui/platform/os;../Gui/generated/fonts/include;../Gui/generated/images/include;../Gui/generated/texts/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F429I-Discovery;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../Gui/generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Regular_12_4bpp.cpp Font_Asap_Regular_20_4bpp.cpp Font_Asap_Regular_22_4bpp.cpp Font_Asap_Regular_36_4bpp.cpp Font_RobotoCondensed_Regular_12_4bpp.cpp Font_SourceSansPro_Regular_100_4bpp.cpp Font_SourceSansPro_Regular_14_4bpp.cpp Font_SourceSansPro_Regular_18_4bpp.cpp Font_SourceSansPro_Regular_64_4bpp.cpp FontGetters.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_20_4bpp.cpp Kerning_Asap_Regular_22_4bpp.cpp Kerning_Asap_Regular_36_4bpp.cpp Kerning_RobotoCondensed_Regular_12_4bpp.cpp Kerning_SourceSansPro_Regular_100_4bpp.cpp Kerning_SourceSansPro_Regular_14_4bpp.cpp Kerning_SourceSansPro_Regular_18_4bpp.cpp Kerning_SourceSansPro_Regular_64_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp Table_Asap_Regular_22_4bpp.cpp Table_Asap_Regular_36_4bpp.cpp Table_RobotoCondensed_Regular_12_4bpp.cpp Table_SourceSansPro_Regular_100_4bpp.cpp Table_SourceSansPro_Regular_14_4bpp.cpp Table_SourceSansPro_Regular_18_4bpp.cpp Table_SourceSansPro_Regular_64_4bpp.cpp
  group Application/User/TouchGFX/generated/images
    ../Gui/generated/images/src/: BitmapDatabase.cpp
  group Application/User/TouchGFX/generated/images/AnimatedGraphics
    ../Gui/generated/images/src/AnimatedGraphics/: animated_graphics_back_button.cpp animated_graphics_back_button_pressed.cpp light_effect_image.cpp
  group Application/User/TouchGFX/generated/images/ChromArt
    ../Gui/generated/images/src/ChromArt/: chrom_art_background.cpp chrom_art_clouds.cpp chrom_art_off_button.cpp chrom_art_on_button.cpp chrom_art_sun.cpp layer_button.cpp layer_button_pressed.cpp st_logo.cpp touchGFX_logo.cpp
  group Application/User/TouchGFX/generated/images/HomeAutomation
    ../Gui/generated/images/src/HomeAutomation/: exit_button.cpp exit_button_pressed.cpp schedule_button.cpp schedule_button_pressed.cpp temperature_adjust_button.cpp temperature_adjust_button_pressed.cpp temperature_cancel_button.cpp temperature_cancel_button_pressed.cpp temperature_jogwheel.cpp temperature_menu_item.cpp temperature_menu_item_selected.cpp temperature_menu_top_day_night.cpp temperature_menu_top_extended.cpp temperature_ok_button.cpp temperature_ok_button_inactive.cpp temperature_ok_button_pressed.cpp temperature_schedule_button_selected.cpp temperature_schedule_menu_item.cpp temperature_schedule_menu_item_selected.cpp temperature_slider.cpp temperature_slider_knop.cpp
  group Application/User/TouchGFX/generated/images/LiveDataDisplay
    ../Gui/generated/images/src/LiveDataDisplay/: weather_background_1.cpp weather_background_2.cpp weather_background_3.cpp weather_background_ending_1.cpp weather_dot_normal.cpp weather_dot_selected.cpp weather_small_icon_cloud.cpp weather_small_icon_shower.cpp weather_small_icon_sun.cpp weather_small_icon_sun_bigcloud.cpp weather_small_icon_thunder.cpp
  group Application/User/TouchGFX/generated/images/Menu
    ../Gui/generated/images/src/Menu/: background_bottom.cpp background_top.cpp menu_item_animated_graphics.cpp menu_item_chrom_art.cpp
  group Application/User/TouchGFX/generated/texts
    ../Gui/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/animated_graphics_screen
    ../Gui/gui/src/animated_graphics_screen/: AnimatedGraphicsPresenter.cpp AnimatedGraphicsView.cpp BumpMapImage.cpp
  group Application/User/TouchGFX/gui/chrom_art_screen
    ../Gui/gui/src/chrom_art_screen/: ChromArtPresenter.cpp ChromArtView.cpp
  group Application/User/TouchGFX/gui/common
    ../Gui/gui/src/common/: DotIndicator.cpp FrontendApplication.cpp
  group Application/User/TouchGFX/gui/home_automation_screen
    ../Gui/gui/src/home_automation_screen/: HomeAutomationPresenter.cpp HomeAutomationView.cpp JogWheel.cpp TemperatureMenuItem.cpp TemperatureScheduleMenuItem.cpp TemperatureSlider.cpp
  group Application/User/TouchGFX/gui/live_data_display_screen
    ../Gui/gui/src/live_data_display_screen/: CityInfo.cpp LiveDataDisplayPresenter.cpp LiveDataDisplayView.cpp WeekInfo.cpp
  group Application/User/TouchGFX/gui/menu_screen
    ../Gui/gui/src/menu_screen/: AnimatedGraphicsTile.cpp ChromArtTile.cpp HomeAutomationTile.cpp LiveDataDisplayTile.cpp MenuPresenter.cpp MenuView.cpp
  group Application/User/TouchGFX/gui/model
    ../Gui/gui/src/model/: Model.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_io.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group Middlewares/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Middlewares/TouchGFX/Target
    ../Gui/target/: BoardConfiguration.cpp GPIO.cpp ResistiveTouchController.cpp STM32F4DMA.cpp STM32F4HAL.cpp STM32F4Instrumentation.cpp
software components: CMSIS:CORE 4.3.0
