# Keil uVision project Project.uvprojx, settings and files
target STM32429I-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32429I-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_FULL_LL_DRIVER,HSE_VALUE=25000000U
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_LL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usart.c stm32f4xx_ll_lptim.c stm32f4xx_ll_rng.c stm32f4xx_ll_i2c.c stm32f4xx_ll_tim.c stm32f4xx_ll_adc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_utils.c stm32f4xx_ll_dac.c stm32f4xx_ll_crc.c stm32f4xx_ll_exti.c stm32f4xx_ll_spi.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_pwr.c stm32f4xx_ll_dma.c stm32f4xx_ll_rcc.c
  group Example/User
    ../Src/: stm32f4xx_it.c main.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s startup_stm32f439xx.s
target STM32439I-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F439NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: STM32439I-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F439xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0
