# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_io.c stm324x9i_eval_nor.c stm324x9i_eval_sdram.c stm324x9i_eval_sd.c stm324x9i_eval_eeprom.c stm324x9i_eval_lcd.c stm324x9i_eval_ts.c stm324x9i_eval.c stm324x9i_eval_sram.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Example/User
    ../Src/: nor.c sd.c sdram.c joystick.c main.c eeprom.c ts_calibration.c stm32f4xx_it.c touchscreen.c lcd.c sram.c log.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_nor.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
software components: CMSIS:CORE 4.1.0
