# IAR project USBH_FWupgrade.ewp, settings and files
configuration STM324x9I-EVAL_USBH-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM324x9I-EVAL_USBH_FS.hex
  ILINK.IlinkOutputFile: STM324x9I-EVAL_USBH-FS.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324x9I-EVAL_USBH-HS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL; USE_USB_HS
  OBJCOPY.OOCOutputFile: STM324x9I-EVAL_USBH_HS.hex
  ILINK.IlinkOutputFile: STM324x9I-EVAL_USBH-HS.out
configuration STM324x9I-EVAL_USBH-HS-IN-FS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL; USE_USB_HS; USE_USB_HS_IN_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL; ..\..\..\..\..\..\Utilities\Log
  OBJCOPY.OOCOutputFile: STM324x9I-EVAL_USBH_HS-IN-FS.hex
  ILINK.IlinkOutputFile: STM324x9I-EVAL_USBH-HS-IN-FS.out
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: command.c flash_if.c iap_menu.c main.c stm32f4xx_it.c usbh_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_io.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio_dma.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
