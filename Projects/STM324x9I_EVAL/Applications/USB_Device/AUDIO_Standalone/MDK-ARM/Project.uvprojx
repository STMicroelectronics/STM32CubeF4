# Keil uVision project Project.uvprojx, settings and files
target STM324x9I-EVAL_USBD-FS (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I-EVAL_USBD-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_FS
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: usbd_desc.c stm32f4xx_it.c usbd_audio_if.c main.c usbd_conf.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Drivers/BSP/STM324x9I-EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_lcd.c stm324x9i_eval_io.c stm324x9i_eval_sdram.c stm324x9i_eval_audio.c stm324x9i_eval.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/STM32_USBD_Library/Class/AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sai_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sai.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pcd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c
target STM324x9I-EVAL_USBD-HS-IN-FS (ARM-ADS)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324x9I-EVAL_USBD-HS-IN-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_USB_HS,USE_USB_HS_IN_FS
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0
