# Keil uVision project Project.uvprojx, settings and files
target STM32412ZG_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144,ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F4xx_Nucleo_144;../../../../Drivers/BSP/Adafruit_Shield;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c fatfs_storage.c
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
software components: CMSIS:CORE 5.0.1
