<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_FWupgrade.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBH_FWupgrade</project>
        <configuration>STM32469I-DISCOVERY_USBH-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


