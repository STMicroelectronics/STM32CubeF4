# Keil uVision project Project.uvprojx, settings and files
target STM32469I-DISCOVERY_USBD-FS (ARM-ADS)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I-DISCOVERY_USBD-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32469I-Discovery;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Application/User
    ../Src/: usbd_desc.c usbd_audio_if.c main.c usbd_conf.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Componentes
    ../../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Middlewares/STM32_USBD_Library/Class/AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Drivers/BSP/STM32469I_Discovery
    ../../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery_audio.c stm32469i_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2s_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_sai.c stm32f4xx_hal_pwr.c
  group Middlewares/Addons/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
software components: CMSIS:CORE 4.1.0
