# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCOVERY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_DISCOVERY
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32469I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c list.c tasks.c
  group Example/User
    ../Src/: stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c main.c
  group Drivers/BSP/STM32469I-Discovery
    ../../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f469xx.s
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
