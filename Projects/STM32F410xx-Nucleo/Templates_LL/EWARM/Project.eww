<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD-ALL</name>
      <member>
        <project>Project</project>
        <configuration>NUCLEO-F410Cx</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>NUCLEO-F410Rx</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>NUCLEO-F410Tx</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


