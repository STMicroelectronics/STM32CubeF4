<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\UART_ReceptionToIdle_CircularDMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
