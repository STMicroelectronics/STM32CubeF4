# Keil uVision project Project.uvprojx, settings and files
target STM32F429ZI-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F429ZI-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,USE_STM32F4XX_NUCLEO_144,ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144;../../../../../../Drivers/BSP/Adafruit_Shield;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c
  group Drivers/BSP/STM32F4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
software components: CMSIS:CORE 4.3.0
