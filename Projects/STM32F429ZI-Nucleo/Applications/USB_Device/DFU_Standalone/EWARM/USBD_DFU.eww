<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_DFU.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBD_DFU</project>
        <configuration>STM32469I-DISCOVERY_USBD</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


